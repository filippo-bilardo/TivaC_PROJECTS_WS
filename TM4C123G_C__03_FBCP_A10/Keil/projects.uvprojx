# Keil uVision project projects.uvprojx, settings and files
target TM4C123G_Projects (5060020::V5.06 (build 20)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: C:\ti\TivaWare_C_Series-2.1.2.111
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source
    ./: startup_rvmdk.S
    ../: main.c
    ../LIBS/: Led.c SysTick.c Uart.c FBCP.c Puls.c
    ../utils/: uartstdio.c
  group Libraries
    C:/ti/TivaWare_C_Series-2.1.1.71/driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
